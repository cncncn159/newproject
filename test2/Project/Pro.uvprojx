# Keil uVision project Pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Code\BSP\app_data;..\Code\BSP\EXTI;..\Code\BSP\LED;..\Code\BSP\SCAN;..\Code\BSP\TIMER;..\Code\Libraries;..\Code\Libraries\CMSIS;..\Code\Libraries\STM32F10x_FWLib\inc;..\Code\BSP\delay;..\Code\BSP\sys;..\Code\BSP\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ../Code/BSP/app_data/: app_data.c
    ../Code/BSP/EXTI/: exti.c
    ../Code/BSP/LED/: led.c
    ../Code/BSP/SCAN/: scan.c
    ../Code/BSP/TIMER/: timer.c
    ../Code/BSP/delay/: delay.c
    ../Code/BSP/sys/: sys.c
    ../Code/BSP/usart/: usart.c
  group USER
    ../Code/: main.c
  group LIB
    ../Code/Libraries/: stm32f10x_it.c
    ../Code/Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Code/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
